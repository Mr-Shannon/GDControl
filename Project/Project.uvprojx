# Keil uVision project Project.uvprojx, settings and files
target GDControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\Application;..\Drivers;..\RT-Thread\include;..\GD32F10xLibrary\GD32F10x_Firmware_Library\Template;..\GD32F10xLibrary\GD32F10x_Firmware_Library\Firmware\CMSIS;..\GD32F10xLibrary\GD32F10x_Firmware_Library\Firmware\Peripherals\inc;..\RT-Thread\Components\Drivers\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c rt_user.c
  group Drivers
    ../Drivers/: led.c usart.c
  group Firmware_Library
    ../GD32F10xLibrary/GD32F10x_Firmware_Library/Firmware/CMSIS/: system_gd32f10x.c
    ../GD32F10xLibrary/GD32F10x_Firmware_Library/Firmware/: startup_gd32f10x_md.s
    ../GD32F10xLibrary/GD32F10x_Firmware_Library/Firmware/Peripherals/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group Kernel
    ../RT-Thread/Kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Cortex-M3
    ../RT-Thread/Cortex-M3/: context_rvds.S backtrace.c cpuport.c showmem.c
  group DeviceDrivers
    ../RT-Thread/Components/Drivers/source/: serial.c
software components: CMSIS:CORE 5.0.1
